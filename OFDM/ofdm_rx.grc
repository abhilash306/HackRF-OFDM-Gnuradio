options:
  parameters:
    generate_options: qt_gui
    id: ofdm_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1500000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_max_xx_0
  id: blocks_max_xx
  parameters:
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000000'
    max_iter: '4000'
    scale: '3.125e-8'
    type: float
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Rx Packets
    type: byte
  states: {state: disabled}
- name: blocks_throttle_2_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-13,-11,-9,-7,-5,-3,-1,1,3,5,7,9,11,13),)
    packet_len_key: '"len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-14,-10,10,14),)
    pilot_symbols: ((1,-1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-3,-1,1,3),)
    packet_len_key: tag_length
    payload_mod: '"QPSK"'
    pilot_carriers: ((-2,2),)
    pilot_symbols: ((1,-1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_1
  id: digital_ofdm_rx
  parameters:
    cp_len: '4'
    fft_len: '16'
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((1,-1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_rx_0_2
  id: digital_ofdm_rx
  parameters:
    cp_len: '2'
    fft_len: '8'
    header_mod: '"BPSK"'
    occupied_carriers: ((-3,-1,1,3),)
    packet_len_key: '"len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-2,2),)
    pilot_symbols: ((1,-1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_3
  id: digital_ofdm_rx
  parameters:
    cp_len: '16'
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: ((-31,-29,-28,-27,-25,-23,-21,-20,-19,-17,-16,-15,-13,-12,-11,-9,-7,-6,-5,-3,-1,1,3,5,6,7,9,11,12,13,15,16,17,19,20,21,23,25,27,28,29,31),)
    packet_len_key: '"len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-30,-22,-10-4,4,10,22,30),)
    pilot_symbols: ((1,-1,1,-1,1,-1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PAPR',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.count =0
              self.powe = 0
              self.peak_power = 0
              self.power = 0
              self.num_samples = 10000
              self.portName = "messageOutput"
              self.message_port_register_out(pmt.intern(self.portName))
              self.repeat = 20
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              for index in range(len(input_items[0])):
                  self.count = self.count+1
                  self.powe = input_items[0][index]*input_items[0][index]
                  if(self.peak_power < self.powe):
                  	self.peak_power =  self.powe
                  self.power = self.power + self.powe
                      
                  if(self.count>=self.num_samples and self.repeat>0):
                  	self.count = 0
                  	self.power = self.power/self.num_samples
                  	self.power = self.peak_power/self.power
                  	#PMT_msg = pmt.from_float(self.power)
                  	#self.message_port_pub(pmt.intern(self.portName), PMT_msg)
                  	self.repeat = self.repeat-1
                  	print("PAPR:")
                  	print(self.power)
                  if(input_items[0][index] == 1):
                      self.error +=1
              output_items[0][:] = input_items[0]
              return len(output_items[0])
              #return 0
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: rtl=0,buffers=128,buflen32768
    bb_gain0: '30'
    bw0: 1e6
    freq0: 700e6
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '30'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: peak power recieved
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: papr
    type: float
  states: {}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: average power recieved
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_3_0
  id: qtgui_time_sink_x
  parameters:
    name: '"transmitted power"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal_to_rx
  states: {state: disabled}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: signal_to_rx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: mov_avg_signal
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: rec_float_signal
  states: {state: disabled}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: max_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_symbol
  states: {state: disabled}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mov_avg_signal
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: max_signal
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {}
- name: virtual_source_6_0
  id: virtual_source
  parameters:
    stream_id: signal_to_rx
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', epy_block_2, '0']
- [blocks_complex_to_real_0, '0', blocks_max_xx_0, '0']
- [blocks_complex_to_real_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_divide_xx_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_max_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_max_xx_0, '0', virtual_sink_5, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_moving_average_xx_0, '0', virtual_sink_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_throttle_2_0, '0', qtgui_time_sink_x_0_3_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', virtual_sink_3, '0']
- [digital_ofdm_rx_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_1, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0_1, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_2, '0', blocks_tag_debug_0, '0']
- [digital_ofdm_rx_0_2, '0', blocks_uchar_to_float_0, '0']
- [epy_block_2, '0', blocks_throttle_2_0, '0']
- [epy_block_2, messageOutput, blocks_message_debug_0, print]
- [osmosdr_source_0, '0', digital_ofdm_rx_0, '0']
- [osmosdr_source_0, '0', digital_ofdm_rx_0_0, '0']
- [osmosdr_source_0, '0', digital_ofdm_rx_0_1, '0']
- [osmosdr_source_0, '0', digital_ofdm_rx_0_2, '0']
- [osmosdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', virtual_sink_0, '0']
- [osmosdr_source_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_1, '0', blocks_divide_xx_0, '1']
- [virtual_source_5, '0', blocks_divide_xx_0, '0']
- [virtual_source_6, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_6_0, '0', blocks_multiply_conjugate_cc_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.4.0

options:
  parameters:
    category: Custom
    description: Transmit a pre-defined signal (a complex sine) as OFDM packets.
    generate_options: qt_gui
    id: ofdm_loopback_example
    output_language: python
    title: OFDM Loopback Example
  states: {}

blocks:
- name: constant
  id: variable_qtgui_range
  parameters:
    label: constant
    outputmsgname: value
    showports: 'False'
    start: '1'
    step: '1'
    stop: '1000'
    value: '1'
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {state: disabled}
- name: fft_len
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '8'
    step: '8'
    stop: '512'
    value: '64'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset (Multiples of Sub-carrier spacing)
    outputmsgname: value
    showports: 'False'
    start: '-3'
    step: '.01'
    stop: '3'
    value: '0'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: (list(range(-26, -21)) + list(range(-20, -7)) + list(range(-6, 0)) + list(range(1, 7)) + list(range(8, 21)) + list(range(22, 27)),)
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-21, -7, 7, 21,),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((1, 1, 1, -1,),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\abhilash\Desktop\ofdm\test1.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\abhilash\Desktop\ofdm\test.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: constant
    type: float
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: freq_offset * 1.0/fft_len
    noise_voltage: noise_voltage
    seed: '0'
    taps: (1.0 + 1.0j, 0.5+0.2j, 0.5-0.5j, 0.5+0.8j, 0.5-0.2j, 0.3-0.3j)
  states: {state: disabled}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0,0.1,1.3)
    fDTs: 10.0/samp_rate
    mags: (1,0.99,0.97)
    ntaps: '16'
    seed: '0'
  states: {}
- name: digital_ofdm_rx_0_3
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-31,-29,-28,-27,-25,-23,-21,-20,-19,-17,-16,-15,-13,-12,-11,-9,-7,-6,-5,-3,-1,1,3,5,6,7,9,11,12,13,15,16,17,19,20,21,23,25,27,28,29,31),)
    packet_len_key: '"len_tag_key"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-30,-22,22,30),)
    pilot_symbols: ((1,-1,1,-1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_2
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-31,-29,-28,-27,-25,-23,-21,-20,-19,-17,-16,-15,-13,-12,-11,-9,-7,-6,-5,-3,-1,1,3,5,6,7,9,11,12,13,15,16,17,19,20,21,23,25,27,28,29,31),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-30,-22,22,30),)
    pilot_symbols: ((1,-1,1,-1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_probe_mpsk_snr_est_c_0
  id: digital_probe_mpsk_snr_est_c
  parameters:
    alpha: '0.01'
    msg_nsamples: '1000'
    type: '0'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      from gnuradio import grc

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='datatypeconversion',   # will show up in GRC
                  in_sig=None,
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.selectPortName = 'snr'
              self.message_port_register_in(pmt.intern(self.selectPortName))
              self.set_msg_handler(pmt.intern(self.selectPortName), self.handle_msg)
              self.snr=0
              #print(222)
          def handle_msg(self,msg):
              self.snr=pmt.to_float(msg)
              #print(22)
              
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print(2)
              output_items[0][:] = abs(self.snr) 
              return len(output_items[0])
  states: {}
- name: fec_ber_bf_0
  id: fec_ber_bf
  parameters:
    berminerrors: '1000'
    test_mode: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum (channel o/p)
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: 'Rx Spectrum '
    showports: 'True'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 5e8
    fftsize: '1024'
    name: '"ofdm tx output"'
    type: complex
  states: {}
- name: qtgui_number_sink_0_0_1
  id: qtgui_number_sink
  parameters:
    color1: ("blue", "red")
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: 'SNR '
    max: '30'
    min: '0'
    name: reciver snr
    type: float
    unit1: dB
  states: {}
- name: qtgui_number_sink_0_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: ber
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Scope Plot ofdm reciever
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"ofdm transmitter output"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_symbol
  states: {}

connections:
- [blocks_char_to_float_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_float_to_char_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_float_to_char_0, '0', fec_ber_bf_0, '0']
- [blocks_interleaved_char_to_complex_0, '0', digital_probe_mpsk_snr_est_c_0, '0']
- [blocks_multiply_const_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_2, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [channels_channel_model_0, '0', blocks_throttle_0, '0']
- [channels_channel_model_0, '0', digital_ofdm_rx_0_3, '0']
- [channels_selective_fading_model_0, '0', blocks_throttle_0, '0']
- [channels_selective_fading_model_0, '0', digital_ofdm_rx_0_3, '0']
- [digital_ofdm_rx_0_3, '0', blocks_file_sink_0, '0']
- [digital_ofdm_rx_0_3, '0', blocks_interleaved_char_to_complex_0, '0']
- [digital_ofdm_rx_0_3, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0_3, '0', fec_ber_bf_0, '1']
- [digital_ofdm_tx_0_2, '0', channels_channel_model_0, '0']
- [digital_ofdm_tx_0_2, '0', channels_selective_fading_model_0, '0']
- [digital_ofdm_tx_0_2, '0', qtgui_freq_sink_x_1, '0']
- [digital_ofdm_tx_0_2, '0', qtgui_time_sink_x_1, '0']
- [digital_probe_mpsk_snr_est_c_0, snr, epy_block_1_0, snr]
- [epy_block_1_0, '0', qtgui_number_sink_0_0_1, '0']
- [fec_ber_bf_0, '0', qtgui_number_sink_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
